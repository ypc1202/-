# Keil uVision project Box.uvproj, settings and files
target Box (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Box +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_221184
  c include: ..\..\Include
  group Box
    ./Code/: Box.c
    ./Startup/: STARTUP.A51
  group Common
    ../../Common/: Delay.c Semaphore.c Version.c Adc.c Clock.c Gpio.c Serial.c Pwm.c I2c.c Spi.c
  group Config
    ../../Config/: Conf_tny.A51
  group Documentation
    ./Documentation/: ABSTRACT.TXT N76E885_Datasheet_V1.00.pdf 24LC64.pdf NXP_I2C.pdf
